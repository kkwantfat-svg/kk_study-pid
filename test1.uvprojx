# Keil uVision project test1.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\USER;.\CMSIS\Include;.\HW\Include;.\LIB\Include;.\SYSTEM\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/Source/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
  group HW
    ./HW/Source/: systick.c stm32f10x_it.c led.c OLED.c OLED_Data.c encoder.c Key.c Moter.c RP.c
  group LIB
    ./LIB/Source/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ./SYSTEM/Source/: timer.c pwm.c usart.c
  group USER
    ./USER/: main.c pid.c
